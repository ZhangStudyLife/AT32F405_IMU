# Keil uVision project imu_readout.uvprojx, settings and files
target AT32F405_IMU (6230000::V6.23::ARMCLANG)
  device: AT32F405KBU7-4 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.1.6
  cpu: IRAM(0x20000000,0x11800) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: imu_readout +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 v6Lto=1 wLevel=2
  c define: AT32F405KBU7_4,USE_STDPERIPH_DRIVER
  c misc: -std=c99 -ffp-model=precise -fno-math-errno
  c include: "$S/Device/Include";"$S/Device/Firmware/Peripherals/inc";./vendor/CMSIS/Core/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x11800
  scatter file: ./imu_readout.sct
  group IMU
    ./: main.c startup_at32f402_405.s lsm6dsv16x.c platform.c imu.c calibration.c storage.c MahonyAhrs.c IMU_Filtter.c uart.c
    $$Device:AT32F405KBU7-4$Device/Source/: system_at32f402_405.c
    $$Device:AT32F405KBU7-4$Device/Firmware/Peripherals/src/: at32f402_405_crm.c at32f402_405_gpio.c at32f402_405_spi.c at32f402_405_dma.c at32f402_405_exint.c at32f402_405_scfg.c at32f402_405_tmr.c at32f402_405_flash.c at32f402_405_pwc.c

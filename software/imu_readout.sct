LR_IROM1 0x08000000 0x0001FC00 {
  ER_IROM1 0x08000000 0x0001FC00 {
    *.o (RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
  }
  RW_IRAM1 0x20000000 0x00011800 {
    .ANY (+RW +ZI)
  }
}

# Repository ZhangStudyLife/AT32F405_IMU

## KiCad design hardware_V2/AT32F405_IMU_V2.kicad_pcb

Parts:
C1: 4.7uF / 10V; C_0603_1608Metric; Voltage 10V; Tolerance 10%
C2, C3, C4, C6, C7, C8: 100nF / 10V; C_0402_1005Metric; Voltage 10V; Tolerance 10%
C5: 1uF / 10V; C_0402_1005Metric; Voltage 10V; Tolerance 10%
C9: 10uF / 10V; C_0603_1608Metric; Voltage 10V; Tolerance 10%
C10, C11: 10pF / C0G; C_0201_0603Metric; Voltage 50V; Tolerance 2%; MPN GRM0335C1H100GA01D
J1: SM04B-GHS-TB; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal; MPN SM04B-GHS-TB
J2: SWD / PADS; SWD_Pads_1x04_P1.27mm
Q1: CSD13380F3; Texas_PicoStar_DFN-3_0.69x0.60mm; MPN CSD13380F3
R1: 2.2k; R_0402_1005Metric; Tolerance 1%
R2: 10k; R_0402_1005Metric; Tolerance 1%
R3, R4, R5, R6: 100R; R_0402_1005Metric; Tolerance 1%; MPN CRCW0402100RFKEDHP
R7: 1k; R_0402_1005Metric; Tolerance 1%
R8: 100k; R_0402_1005Metric; Tolerance 1%
U1: AT32F405KBU7-4; AT32F405_QFN32_4x4_P0.4_EP2.7; MPN AT32F405KBU7-4
U2: LSM6DSV16X; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y; MPN LSM6DSV16X
Y1: 24MHz / CL8pF; Crystal_ABM12W_1612; Tolerance 10ppm initial / 20ppm temperature; MPN ABM12W-24.0000MHZ-8-D1X-T3

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, C9.1, J1.2 (3V3), J2.1, R2.1, R3.1, R4.1, R5.1, R6.1, U1.1 (VDD), U1.5 (VDDA), U1.20 (VDD), U2.5 (VDD_IO), U2.8 (VDD)
/HEATER_PWM: R7.1, U1.6 (PA0/TMR2_CH1)
/IMU_CS_N: R2.2, U1.10 (PA4), U2.12 (CS)
/IMU_INT1: U1.14 (PB0), U2.4 (INT1)
/IMU_MISO: U1.12 (PA6), U2.1 (SDO/SA0)
/IMU_MOSI: U1.13 (PA7), U2.14 (SDA/SDI)
/IMU_SCK: U1.11 (PA5), U2.13 (SCL/SPC)
/NRST: C6.1, U1.4 (NRST)
/SWCLK: J2.4, U1.24 (PA14/SWCLK)
/SWDIO: J2.3, U1.23 (PA13/SWDIO)
/UART_RX: J1.4 (RX), U1.9 (PA3)
/UART_TX: J1.3 (TX), U1.8 (PA2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.1 (GND), J2.2, Q1.2 (S), R1.2, R8.2, U1.33 (VSS/VSSA), U2.2 (SDx/AH1/Qvar1), U2.3 (SCx/AH2/Qvar2), U2.6 (GND), U2.7 (GND), Y1.2 (G), Y1.4 (G)
unnamed: Q1.3 (D), R3.2, R4.2, R5.2, R6.2
unnamed: Q1.1 (G), R7.2, R8.1
unnamed: C10.1, U1.2 (PF0), Y1.1
unnamed: C11.1, U1.3 (PF1), Y1.3
unnamed: R1.1, U1.31 (PF11/BOOT0)

Notes on the sheet:
3.3V 外部供电 / SPI 采集 / UART 921600 / GH1.25 四针卧贴
04 下载调试与恒温控制要求
J2：背面焊盘，间距1.27mm；1=3V3，2=GND，3=SWDIO，4=SWCLK。 3V3 作 VTref；外部供电时不并接下载器电源。
C2/C3：各 VDD 去耦；C4/C5：VDDA 去耦。 EPAD 33 必须焊接；BOOT0 使用 2.2k 下拉。
目标 55°C 须校准；65°C 软件关断，无独立硬件过温保护。 内温 SPI 0x20/21：25 + raw/256；偏移可达 ±15°C（DS13510 Rev2 p15）。PWM 20kHz / PI 10Hz 起调。 建议整板预留 250mA；最高自然温度宜 ≤45–50°C，低温加热能力须实测。超时关断，启用看门狗。
AT32F405 + LSM6DSV16X 恒温 IMU
01 接口与供电
Y1：1612 / 24MHz / CL=8pF C10/C11：0201 / C0G / 50V / ±2% 10pF 为首板初值，须实测微调； 晶体与电容紧贴 PF0/PF1，避开加热回路。
05 恒温加热
恒温版 · 24MHz 晶体 · 24 颗实装器件 · 阻容 0402，C1/C9 为 0603，晶振电容 0201
Mode 1；INT1 配置为推挽输出。 2/3 脚接地；9/10/11 脚不连接。 CS 上拉保证 MCU 单独复位时保持高。 C7/C8 分别贴近 VDD_IO / VDD。
24MHz HEXT + PLL；SWD 下载
02 MCU 最小系统
03 IMU 采集
HEXT + PLL：PCLK1=48MHz，USART2 DIV=52；目标 921600。 标称 923077 baud，分频误差 +0.16%；振荡器误差另计。 未用 USB PHY 按 FAQ0148 关闭；调用前启用 PLL 或 HEXT。 恒温参数及 UART 均须实测；外部电源需承担加热脉冲电流。
4×100Ω · 0402 / 0.2W HP
R3–R6：CRCW0402100RFKEDHP，四点对称。 3.3V 满开 132mA / 0.436W；C9：X7R / 0603。 禁用 1/16W 替换；Q1 1=G / 2=S / 3=D。
六轴惯性采集 · SPI / INT1 · LGA14 2.5 × 3.0 mm
1 GND · 2 3V3 · 3 TX · 4 RX TX/RX 以本板为准，与主机交叉连接。

Board: 4 copper layers, 18.6 x 18.6 mm, 29 parts (4 on the bottom side), 18 nets.

Other parts of the board:
H1, H2, H3, H4: M2 / NPTH 2.2mm; M2_2.2mm_Compact
